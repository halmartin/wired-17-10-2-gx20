FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-cinterion-Add-SIM-hot-swap-to-AT-broadband-modems-PL.patch"
