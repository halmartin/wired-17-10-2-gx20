FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-remove-Wno-cast-function-type-since-it-s-not-present.patch"

