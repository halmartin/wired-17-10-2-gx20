FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://60-add-specific-test-option.patch"
